# Keil uVision project 1.uvproj, settings and files
target Target 1 (166/167)
  device: C167CR-L25M Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xE000-0xE7FF) ICAN(0xE800-0xEFFF) CLOCK(25000000) MOD167
  output: 1 +hex
  group Source Group 1
    ./: START167.A66 main.c apd_functions.c tdc_functions.c measure_dist.c timer.c timer.h
